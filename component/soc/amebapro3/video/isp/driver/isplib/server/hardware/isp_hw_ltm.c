/*
 * Realtek Semiconductor Corp.
 * Copyright (C) 2017 Grant Shen <grant_shen@realsil.com.cn>
 */

#include <math.h>
#include <isp_utils.h>
#include <isp_reg_virtual.h>
#include <isp_reg_tm.h>
#include "isp_hw_ltm.h"

#define MOD_NAME TM

static void isp_hw_edgeness_slope(FW_EST_MOD_INFO mod_info)
{
	int edge_rate_max = READ_REG(mod_info, EDGE_RATE_MAX);
	int edge_rate_min = READ_REG(mod_info, EDGE_RATE_MIN);
	int edge_offset_long = READ_REG(mod_info, EDGE_OFFSET_LONG);
	int edge_offset_short = READ_REG(mod_info, EDGE_OFFSET_SHORT);
	int edgeness_slope_long =
		(uint32_t)((float)(edge_rate_max - edge_rate_min) /
				   (float)(edge_offset_long) * 4096.0);
	int edgeness_slope_short =
		(uint32_t)((float)(edge_rate_max - edge_rate_min) /
				   (float)(edge_offset_short) * 4096.0);

	WRITE_REG(mod_info, EDGENESS_SLOPE_LONG, edgeness_slope_long);
	WRITE_REG(mod_info, EDGENESS_SLOPE_SHORT, edgeness_slope_short);
}

static void isp_hw_ltm_set_alpha_table(FW_EST_MOD_INFO mod_info, uint16_t alpha,
									   uint8_t is_hdr)
{
	int i;

	for (i = 0; i < 10; i++) {
		if (is_hdr)
			WRITE_REG_ARRAY_I(mod_info, LTM_ALPHA_TABLE_HDR, i,
							  alpha);
		else
			WRITE_REG_ARRAY_I(mod_info, LTM_ALPHA_TABLE_LINEAR, i,
							  alpha);
	}
}

static uint16_t isp_hw_ltm_calc_alpha(FW_EST_MOD_INFO mod_info, uint32_t weight,
									  uint32_t curve_base_val)
{
	uint16_t alpha;
	uint32_t k0;
	uint32_t k1;
	uint32_t dark_slope_m;
	float m0;
	float m1;
	float numerator;
	float denominator;

	if (weight < 256) {
		k0 = READ_VIRT_REG(mod_info, VLTM_K0);
		k1 = READ_VIRT_REG(mod_info, VLTM_K1);
	} else {
		weight -= 256;
		k0 = READ_VIRT_REG(mod_info, VLTM_K1);
		k1 = READ_VIRT_REG(mod_info, VLTM_K2);
	}

	if (READ_REG(mod_info, GLOBAL_TONE_MAPPING_EN))
		m0 = clamp(curve_base_val, (uint32_t)4096, (uint32_t)16383) /
			 4096.0f;
	else {
		m0 = 4.0f;
	}
	m1 = linear_intp(weight, 0, k0, 256, k1) / 512.0f;
	dark_slope_m = READ_VIRT_REG(mod_info, VLTM_DARK_SLOPE_M) / 1024.0f;

	if (m0 < dark_slope_m && m1 >= 1.0) {
		numerator = dark_slope_m - m0;
		denominator = (m0 * (m1 - 1.0));
		if (numerator >= denominator) {
			alpha = 256;
		} else {
			alpha = (numerator / denominator) * 256;
			alpha = clamp_t(uint16_t, alpha, 0, 256);
		}
	} else {
		alpha = 0;
	}
	return alpha;
}

static void isp_hw_ltm_update_alpha_table(FW_EST_MOD_INFO mod_info)
{
	uint32_t weight;
	uint16_t alpha;

	weight = READ_REG(mod_info, LTM_WEIGHT_LINEAR);
	alpha = isp_hw_ltm_calc_alpha(mod_info, weight,
								  READ_REG(mod_info, GTM_TABLE_LINEAR_0));
	isp_hw_ltm_set_alpha_table(mod_info, alpha, 0);

	weight = READ_REG(mod_info, LTM_WEIGHT_HDR);
	alpha = isp_hw_ltm_calc_alpha(mod_info, weight,
								  READ_REG(mod_info, GTM_TABLE_HDR_0));
	isp_hw_ltm_set_alpha_table(mod_info, alpha, 1);
}

static int isp_hw_ltm_est_dynamic(FW_EST_MOD_INFO mod_info)
{
	isp_hw_ltm_update_alpha_table(mod_info);
	isp_hw_edgeness_slope(mod_info);

	return 0;
}

static void isp_hw_gcac_info(FW_EST_MOD_INFO mod_info, int w, int h)
{
	int ocx_r = READ_REG(mod_info, OCX_R);
	int ocy_r = READ_REG(mod_info, OCY_R);
	int ocx_b = READ_REG(mod_info, OCX_B);
	int ocy_b = READ_REG(mod_info, OCY_B);

	if (ocx_r == 0) {
		ocx_r = w / 2;
	}
	if (ocy_r == 0) {
		ocy_r = h / 2;
	}
	if (ocx_b == 0) {
		ocx_b = w / 2;
	}
	if (ocy_b == 0) {
		ocy_b = h / 2;
	}

	// output
	int rad0_r_reg;
	int E0_r_reg;
	int rad0_b_reg;
	int E0_b_reg;

	// local value
	int px0_r;
	int py0_r;
	int px0_b;
	int py0_b;

	//(x,y)-->(px,py) xy coordination tranfer to polo coordination
	px0_r = 0 - ocx_r;
	py0_r = 0 - ocy_r;
	px0_b = 0 - ocx_b;
	py0_b = 0 - ocy_b;

	// E0, rad0 using for py value
	// E1, rad1 using for px value
	rad0_r_reg = (int)sqrt(px0_r * px0_r + py0_r * py0_r);
	E0_r_reg = rad0_r_reg * rad0_r_reg - px0_r * px0_r - py0_r * py0_r;
	rad0_b_reg = (int)sqrt(px0_b * px0_b + py0_b * py0_b);
	E0_b_reg = rad0_b_reg * rad0_b_reg - px0_b * px0_b - py0_b * py0_b;

	// update reg
	WRITE_REG(mod_info, OCX_R, ocx_r);
	WRITE_REG(mod_info, OCY_R, ocy_r);
	WRITE_REG(mod_info, OCX_B, ocx_b);
	WRITE_REG(mod_info, OCY_B, ocy_b);

	WRITE_REG(mod_info, RAD0_R_REG, rad0_r_reg);
	WRITE_REG(mod_info, E0_R_REG, E0_r_reg);
	WRITE_REG(mod_info, RAD0_B_REG, rad0_b_reg);
	WRITE_REG(mod_info, E0_B_REG, E0_b_reg);
}

static int isp_hw_gcac_est_size_update(FW_EST_MOD_INFO mod_info, int w, int h)
{
	isp_hw_gcac_info(mod_info, w, h);

	return 0;
}

static void init_tm_cfgs(FW_EST_MOD_INFO mod_info)
{
	WRITE_REG(mod_info, EDGE_MAP_MODE, 0); //LTM
	WRITE_REG(mod_info, EPF_MAX_AUTO_MODE, 1); //LTM
	WRITE_REG(mod_info, GLOBAL_EPF_MEAN_SHOW_EN, 0); //LTM
	WRITE_REG(mod_info, GLOBAL_LOCAL_MEAN_SHOW_EN, 0); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_AUTO_MODE, 1); //LTM
	WRITE_REG(mod_info, GLOBAL_TONE_MAPPING_EN, 1); //LTM
	WRITE_REG(mod_info, LOCAL_TONE_MAPPING_EN, 1); //LTM
	WRITE_REG(mod_info, EDGE_OFFSET_LONG, 192); //LTM
	WRITE_REG(mod_info, EDGE_OFFSET_SHORT, 192); //LTM
	WRITE_REG(mod_info, EDGENESS_SLOPE_LONG, 2731); //LTM
	WRITE_REG(mod_info, EDGENESS_SLOPE_SHORT, 2731); //LTM
	WRITE_REG(mod_info, EDGE_RATE_MAX, 128); //LTM
	WRITE_REG(mod_info, EDGE_RATE_MIN, 0); //LTM
	WRITE_REG(mod_info, EPF_MAX_STEP, 0); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_REG, 256); //LTM
	WRITE_REG(mod_info, EPF_MAX_INI_HDR, 4096); //LTM
	WRITE_REG(mod_info, EPF_MAX_INI_LINEAR, 4096); //LTM
	WRITE_REG(mod_info, LTM_WEIGHT_HDR, 512); //LTM
	WRITE_REG(mod_info, LTM_WEIGHT_LINEAR, 0); //LTM
	WRITE_REG(mod_info, DIRECTION_K_0, 4); //LTM
	WRITE_REG(mod_info, DIRECTION_K_1, 8); //LTM
	WRITE_REG(mod_info, DIRECTION_K_2, 12); //LTM
	WRITE_REG(mod_info, DIRECTION_W_0, 209); //LTM
	WRITE_REG(mod_info, DIRECTION_W_1, 169); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_0, 2); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_1, 7); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_2, 9); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_3, 13); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_4, 18); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_5, 22); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_6, 26); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_7, 31); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_8, 36); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_9, 44); //LTM
	WRITE_REG(mod_info, EDGE_THD0_LONG_10, 51); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_0, 2); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_1, 7); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_2, 9); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_3, 13); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_4, 18); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_5, 22); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_6, 26); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_7, 31); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_8, 36); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_9, 44); //LTM
	WRITE_REG(mod_info, EDGE_THD0_SHORT_10, 51); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_0, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_1, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_2, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_3, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_4, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_5, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_6, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_7, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_8, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_HDR_9, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_0, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_1, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_2, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_3, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_4, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_5, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_6, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_7, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_8, 256); //LTM
	WRITE_REG(mod_info, LTM_ALPHA_TABLE_LINEAR_9, 256); //LTM
}

static void __init_tm_cfgs(uint32_t isp_id)
{
	struct isp_hw_mod_info info;

	info.isp_id = isp_id;
	info.chan_offset = 0;

	init_tm_cfgs(&info);
}

static const uint16_t gtm_curves[] = {
	0x2000, 0x2D41, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x2000, 0x2D41, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x2000, 0x2D41, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x2000, 0x2851, 0x32CB, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x2000, 0x260D, 0x2D41, 0x35D1, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x2000, 0x24C2, 0x2A39, 0x3080,
	0x37B7, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x2000, 0x23EB, 0x2851,
	0x2D41, 0x32CB, 0x3904, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x2000, 0x2354,
	0x2702, 0x2B11, 0x2F8D, 0x3480, 0x39F7, 0x3FFF, 0x3FFF, 0x3FFF, 0x2000,
	0x22E5, 0x260D, 0x297F, 0x2D41, 0x3159, 0x35D1, 0x3AB0, 0x3FFF, 0x3FFF,
	0x2000, 0x228F, 0x2554, 0x2851, 0x2B8B, 0x2F08, 0x32CB, 0x36DD, 0x3B41,
	0x3FFF,
};
static const uint16_t ltm_curves[] = {
	0x0000, 0x062B, 0x0ED8, 0x1673, 0x1D16, 0x22D9, 0x27D2, 0x2C18, 0x2FBE,
	0x32D6, 0x3570, 0x379D, 0x396B, 0x3AE5, 0x3C18, 0x3D0F, 0x3DD3, 0x3E6B,
	0x3EE0, 0x3F39, 0x3F7A, 0x3FA9, 0x3FCA, 0x3FE0, 0x3FEE, 0x3FF7, 0x3FFC,
	0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x062B, 0x0ED8,
	0x1673, 0x1D16, 0x22D9, 0x27D2, 0x2C18, 0x2FBE, 0x32D6, 0x3570, 0x379D,
	0x396B, 0x3AE5, 0x3C18, 0x3D0F, 0x3DD3, 0x3E6B, 0x3EE0, 0x3F39, 0x3F7A,
	0x3FA9, 0x3FCA, 0x3FE0, 0x3FEE, 0x3FF7, 0x3FFC, 0x3FFE, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0433, 0x0BE2, 0x1433, 0x1B6A, 0x21A4,
	0x26FC, 0x2B8B, 0x2F68, 0x32A9, 0x3561, 0x37A2, 0x397D, 0x3AFE, 0x3C35,
	0x3D2C, 0x3DED, 0x3E83, 0x3EF4, 0x3F49, 0x3F87, 0x3FB2, 0x3FD0, 0x3FE4,
	0x3FF1, 0x3FF8, 0x3FFD, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x01E8, 0x07A1, 0x112A, 0x1B79, 0x23C5, 0x2A65, 0x2FA3, 0x33BF,
	0x36F0, 0x3962, 0x3B3E, 0x3CA2, 0x3DA9, 0x3E67, 0x3EEF, 0x3F4F, 0x3F90,
	0x3FBB, 0x3FD7, 0x3FE9, 0x3FF4, 0x3FFA, 0x3FFD, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x00B0, 0x03E5,
	0x0ABC, 0x1609, 0x21F5, 0x2AC3, 0x3130, 0x35D2, 0x391E, 0x3B6D, 0x3D04,
	0x3E18, 0x3ED0, 0x3F47, 0x3F92, 0x3FC1, 0x3FDD, 0x3FEE, 0x3FF7, 0x3FFC,
	0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0036, 0x01B2, 0x05BA, 0x0D94, 0x1A84,
	0x27AE, 0x307C, 0x3648, 0x3A08, 0x3C6A, 0x3DE5, 0x3ECC, 0x3F55, 0x3FA4,
	0x3FD0, 0x3FE8, 0x3FF5, 0x3FFB, 0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0024, 0x0122, 0x03D4, 0x0913, 0x11BA, 0x1EA1, 0x2B1A, 0x3329,
	0x3846, 0x3B74, 0x3D64, 0x3E8B, 0x3F36, 0x3F96, 0x3FCA, 0x3FE6, 0x3FF4,
	0x3FFB, 0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x001A, 0x00CD,
	0x02B5, 0x066B, 0x0C88, 0x15A8, 0x2263, 0x2E2E, 0x3582, 0x39F7, 0x3C9E,
	0x3E28, 0x3F07, 0x3F81, 0x3FC2, 0x3FE3, 0x3FF3, 0x3FFA, 0x3FFE, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0007, 0x004C, 0x0139, 0x0358, 0x074D,
	0x0DD1, 0x17B3, 0x25D1, 0x3245, 0x3901, 0x3C8B, 0x3E5A, 0x3F3E, 0x3FAB,
	0x3FDC, 0x3FF2, 0x3FFB, 0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0002, 0x001A, 0x0081, 0x0199, 0x03E6, 0x0816, 0x0EFB, 0x198E,
	0x28EF, 0x35B3, 0x3B92, 0x3E2C, 0x3F47, 0x3FBB, 0x3FE7, 0x3FF8, 0x3FFD,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0001, 0x0012,
	0x005B, 0x011F, 0x02BC, 0x05AC, 0x0A81, 0x11EC, 0x1CB5, 0x2BC1, 0x37A4,
	0x3CB2, 0x3EC1, 0x3F8E, 0x3FDA, 0x3FF4, 0x3FFC, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0001, 0x000D, 0x0042, 0x00CF, 0x01FA,
	0x0419, 0x0798, 0x0CF4, 0x14C0, 0x1FA0, 0x2E4D, 0x3952, 0x3D9A, 0x3F30,
	0x3FBD, 0x3FEC, 0x3FFB, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0001, 0x000A, 0x0031, 0x009A, 0x0177, 0x0309, 0x05A0, 0x0999,
	0x0F60, 0x176F, 0x224F, 0x3097, 0x3AC2, 0x3E51, 0x3F7E, 0x3FDC, 0x3FF7,
	0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0007,
	0x0025, 0x0074, 0x011C, 0x024C, 0x0442, 0x0743, 0x0BA2, 0x11BB, 0x19F5,
	0x24C3, 0x32A3, 0x3BF7, 0x3EDD, 0x3FB4, 0x3FEE, 0x3FFC, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0002, 0x000D, 0x0030, 0x0083,
	0x0129, 0x0252, 0x043A, 0x072F, 0x0B8B, 0x11B9, 0x1A38, 0x2596, 0x3476,
	0x3D6F, 0x3F7B, 0x3FE8, 0x3FFC, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0001, 0x0004, 0x0013, 0x0039, 0x008E, 0x0132, 0x0255,
	0x0435, 0x071F, 0x0B78, 0x11B9, 0x1A71, 0x264D, 0x3615, 0x3E7A, 0x3FCB,
	0x3FFA, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0003, 0x000E, 0x002A, 0x0069, 0x00E4, 0x01BC, 0x0320, 0x054B, 0x0887,
	0x0D2C, 0x13A8, 0x1C79, 0x2833, 0x3782, 0x3EF8, 0x3FE4, 0x3FFE, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0002, 0x000A, 0x0020,
	0x0050, 0x00AC, 0x014F, 0x025C, 0x03FF, 0x0670, 0x09F3, 0x0ED8, 0x1580,
	0x1E5C, 0x29EC, 0x38C3, 0x3F56, 0x3FF3, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0000, 0x0002, 0x0008, 0x0018, 0x003D, 0x0084, 0x0101,
	0x01CF, 0x0310, 0x04EE, 0x079F, 0x0B5F, 0x1078, 0x1741, 0x201C, 0x2B7A,
	0x39DC, 0x3F98, 0x3FFA, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0001, 0x0006, 0x0013, 0x002F, 0x0066, 0x00C7, 0x0167, 0x0260, 0x03D3,
	0x05E9, 0x08D2, 0x0CC6, 0x1209, 0x18E8, 0x21B9, 0x2CE2, 0x3AD0, 0x3FC4,
	0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0001, 0x0005, 0x000F,
	0x0025, 0x0050, 0x009C, 0x011A, 0x01DD, 0x0300, 0x04A3, 0x06EB, 0x0A06,
	0x0E27, 0x138B, 0x1A76, 0x2337, 0x2E25, 0x3BA3, 0x3FE0, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0000, 0x0001, 0x0004, 0x000C, 0x001D, 0x0040, 0x007C,
	0x00DF, 0x017A, 0x0261, 0x03AD, 0x057C, 0x07F2, 0x0B38, 0x0F7E, 0x14FB,
	0x1BEB, 0x2496, 0x2F48, 0x3C58, 0x3FF1, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0001, 0x0003, 0x0009, 0x0018, 0x0033, 0x0063, 0x00B3, 0x012F, 0x01E8,
	0x02F1, 0x0464, 0x065C, 0x08FB, 0x0C67, 0x10CB, 0x1659, 0x1D49, 0x25D9,
	0x304D, 0x3CF4, 0x3FFA, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0001, 0x0003, 0x0008,
	0x0013, 0x0029, 0x0050, 0x0090, 0x00F4, 0x018A, 0x0260, 0x038C, 0x0523,
	0x0741, 0x0A04, 0x0D8F, 0x120C, 0x17A6, 0x1E90, 0x2701, 0x3138, 0x3D79,
	0x3FFE, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0002, 0x0006, 0x000F, 0x0021, 0x0041,
	0x0076, 0x00C7, 0x0141, 0x01EF, 0x02E3, 0x042F, 0x05E8, 0x0827, 0x0B0A,
	0x0EB1, 0x1341, 0x18E2, 0x1FC2, 0x2813, 0x320C, 0x3DEA, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0002, 0x0005, 0x000D, 0x001B, 0x0036, 0x0060, 0x00A3, 0x0107,
	0x0196, 0x025E, 0x036E, 0x04D8, 0x06B0, 0x090F, 0x0C0E, 0x0FCB, 0x146A,
	0x1A0D, 0x20E0, 0x290E, 0x32CB, 0x3E4B, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0004,
	0x000A, 0x0017, 0x002C, 0x0050, 0x0087, 0x00D9, 0x0150, 0x01F5, 0x02D6,
	0x0401, 0x0587, 0x077C, 0x09F5, 0x0D0D, 0x10DE, 0x1586, 0x1B29, 0x21EC,
	0x29F7, 0x3378, 0x3E9F, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0004, 0x0009, 0x0013, 0x0025,
	0x0042, 0x0070, 0x00B5, 0x0117, 0x01A1, 0x025C, 0x0354, 0x0499, 0x0639,
	0x0849, 0x0ADB, 0x0E07, 0x11E7, 0x1698, 0x1C37, 0x22E8, 0x2AD0, 0x3416,
	0x3EE7, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0001, 0x0003, 0x0007, 0x0010, 0x001F, 0x0037, 0x005E, 0x0097,
	0x00EA, 0x015D, 0x01F9, 0x02C9, 0x03D9, 0x0536, 0x06EF, 0x0916, 0x0BBE,
	0x0EFD, 0x12E9, 0x179E, 0x1D38, 0x23D6, 0x2B9A, 0x34A8, 0x3F28, 0x3FFF,
	0x3FFF, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0002,
	0x0006, 0x000D, 0x001A, 0x002F, 0x004F, 0x007F, 0x00C5, 0x0126, 0x01A9,
	0x0259, 0x033E, 0x0463, 0x05D7, 0x07A7, 0x09E3, 0x0C9F, 0x0FED, 0x13E4,
	0x189B, 0x1E2D, 0x24B7, 0x2C57, 0x352F, 0x3F62, 0x3FFF, 0x3FFF, 0x3FFF,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0002, 0x0005, 0x000B, 0x0016,
	0x0028, 0x0043, 0x006C, 0x00A7, 0x00F9, 0x0168, 0x01FD, 0x02BF, 0x03B7,
	0x04F2, 0x067B, 0x0860, 0x0AB0, 0x0D7D, 0x10D8, 0x14D7, 0x198F, 0x1F18,
	0x258E, 0x2D0B, 0x35AE, 0x3F99, 0x3FFF, 0x3FFF, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0001, 0x0002, 0x0004, 0x000A, 0x0013, 0x0022, 0x0039, 0x005C,
	0x008E, 0x00D4, 0x0133, 0x01B1, 0x0256, 0x032A, 0x0436, 0x0585, 0x0722,
	0x091A, 0x0B7C, 0x0E58, 0x11BF, 0x15C3, 0x1A7A, 0x1FFA, 0x265A, 0x2DB5,
	0x3627, 0x3FCD, 0x3FFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0002,
	0x0004, 0x000A, 0x0013, 0x0022, 0x0039, 0x005C, 0x008E, 0x00D4, 0x0133,
	0x01B1, 0x0256, 0x032A, 0x0436, 0x0585, 0x0722, 0x091A, 0x0B7C, 0x0E58,
	0x11BF, 0x15C3, 0x1A7A, 0x1FFA, 0x265A, 0x2DB5, 0x3627, 0x3FCD, 0x3FFF,
};

static void __init_gtm_curves(const uint16_t gtm_values[100], uint32_t base)
{
	int i;
	uint32_t gtm_offset;

	for (i = 0, gtm_offset = base; i < 100; i++, gtm_offset += 4) {
		isp_write_reg(gtm_values[i], gtm_offset);
	}
}

static void __init_ltm_curves(const uint16_t ltm_params[33 * 33], uint32_t base)
{
	int i;
	int j;
	int mem_size[4] = { 17 * 17, 17 * 16, 16 * 17, 16 * 16 };
	int mem_base[4] = { 0 };

	for (i = 1; i < 4; i++) {
		mem_base[i] = mem_base[i - 1] + mem_size[i - 1];
	}

	for (i = 0; i < 33; i++) {
		for (j = 0; j < 33; j++) {
			uint32_t value;
			uint32_t offset;
			int mem_index = (i & 1) * 2 + (j & 1);

			value = ltm_params[i * 33 + j];
			offset = i / 2 * (17 - (j & 1)) + j / 2;
			offset += mem_base[mem_index];
			offset = base + offset * 4;
			isp_write_reg(value, offset);
		}
	}
}

static int isp_hw_ltm_init_vreg(uint32_t isp_id)
{
	uint32_t k;

	k = ltm_curves[34] - ltm_curves[0];
	isp_write_vreg(k, VLTM_K0);
	isp_write_vreg(k, VLTM_K1);
	isp_write_vreg(k, VLTM_K2);
	isp_write_vreg(4096, VLTM_DARK_SLOPE_M);

	return RTS_ISP_OK;
}

static int isp_hw_ltm_init(uint32_t isp_id)
{
	__init_tm_cfgs(isp_id);

	__init_gtm_curves(gtm_curves, TM_GTM_TABLE_LINEAR_0);
	__init_gtm_curves(gtm_curves, TM_GTM_TABLE_HDR_0);

	__init_ltm_curves(ltm_curves, TM_MEM_LTM_TABLE_REF_0_BASE);
	__init_ltm_curves(ltm_curves, TM_MEM_LTM_TABLE_REF_1_BASE);
	__init_ltm_curves(ltm_curves, TM_MEM_LTM_TABLE_REF_2_BASE);

	return RTS_ISP_OK;
}

static int isp_hw_ltm_estimation(uint32_t isp_id)
{
	struct isp_hw_mod_info info;

	info.isp_id = isp_id;
	info.chan_offset = 0;

	isp_hw_ltm_est_dynamic(&info);
	isp_write_reg(VHDRTM_REG_LOAD_MASK, TM_REG_LOAD);

	return RTS_ISP_OK;
}

static int isp_hw_ltm_set_size(uint32_t isp_id, const rts_isp_rect_t *rect)
{
	struct isp_hw_mod_info info;

	info.isp_id = isp_id;
	info.chan_offset = 0;

	return isp_hw_gcac_est_size_update(&info, rect->size.w, rect->size.h);
}

static const struct isp_hw_ltm_ops hw_ltm_ops = {
	.init_vreg = isp_hw_ltm_init_vreg,
	.init_ltm = isp_hw_ltm_init,
	.est_dynamic = isp_hw_ltm_estimation,
	.set_size = isp_hw_ltm_set_size,
};

const struct isp_hw_ltm_ops *isp_hw_ltm_get_ops(void)
{
	return &hw_ltm_ops;
}
