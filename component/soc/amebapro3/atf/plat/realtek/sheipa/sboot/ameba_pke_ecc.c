#define __FPU_PRESENT			1
#define __CORTEX_A				7
#include "cmsis_ca/core_ca.h"
#include "basic_types.h"
#include "hal_platform.h"
#include "sysreg_syson.h"

#include "ameba_vector.h"
#include "ameba_gdma.h"
#include "ameba_key_management_hmac.h"
#include "ameba_sha.h"

#include "ameba_crypto.h"
#include "ameba_pke.h"

#include <stdio.h>
#include <string.h>

/* SEC2: Recommended Elliptic Curve Domain Parameters Ver. 1.0 */
static const uint8_t pke_ecc_curve_secp192r1_p[24] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp192r1_a[24] = {0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp192r1_b[24] = {0xb1, 0xb9, 0x46, 0xc1, 0xec, 0xde, 0xb8, 0xfe, 0x49, 0x30, 0x24, 0x72, 0xab, 0xe9, 0xa7, 0x0f, 0xe7, 0x80, 0x9c, 0xe5, 0x19, 0x05, 0x21, 0x64};
static const uint8_t pke_ecc_curve_secp192r1_n[24] = {0x31, 0x28, 0xd2, 0xb4, 0xb1, 0xc9, 0x6b, 0x14, 0x36, 0xf8, 0xde, 0x99, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp192r1_gx[24] = {0x12, 0x10, 0xff, 0x82, 0xfd, 0x0a, 0xff, 0xf4, 0x00, 0x88, 0xa1, 0x43, 0xeb, 0x20, 0xbf, 0x7c, 0xf6, 0x90, 0x30, 0xb0, 0x0e, 0xa8, 0x8d, 0x18};
static const uint8_t pke_ecc_curve_secp192r1_gy[24] = {0x11, 0x48, 0x79, 0x1e, 0xa1, 0x77, 0xf9, 0x73, 0xd5, 0xcd, 0x24, 0x6b, 0xed, 0x11, 0x10, 0x63, 0x78, 0xda, 0xc8, 0xff, 0x95, 0x2b, 0x19, 0x07};
static const uint8_t pke_ecc_curve_secp192r1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp192k1_p[24] = {0x37, 0xee, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp192k1_a[1] = {0x00};
static const uint8_t pke_ecc_curve_secp192k1_b[1] = {0x03};
static const uint8_t pke_ecc_curve_secp192k1_n[24] = {0x8d, 0xfd, 0xde, 0x74, 0x6a, 0x46, 0x69, 0x0f, 0x17, 0xfc, 0xf2, 0x26, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp192k1_gx[24] = {0x7d, 0x6c, 0xe0, 0xea, 0xb1, 0xd1, 0xa5, 0x1d, 0x34, 0xf4, 0xb7, 0x80, 0x02, 0x7d, 0xb0, 0x26, 0xae, 0xe9, 0x57, 0xc0, 0x0e, 0xf1, 0x4f, 0xdb};
static const uint8_t pke_ecc_curve_secp192k1_gy[24] = {0x9d, 0x2f, 0x5e, 0xd9, 0x88, 0xaa, 0x82, 0x40, 0x34, 0x86, 0xbe, 0x15, 0xd0, 0x63, 0x41, 0x84, 0xa7, 0x28, 0x56, 0x9c, 0x6d, 0x2f, 0x2f, 0x9b};
static const uint8_t pke_ecc_curve_secp192k1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp224r1_p[28] = {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp224r1_a[28] = {0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp224r1_b[28] = {0xb4, 0xff, 0x55, 0x23, 0x43, 0x39, 0x0b, 0x27, 0xba, 0xd8, 0xbf, 0xd7, 0xb7, 0xb0, 0x44, 0x50, 0x56, 0x32, 0x41, 0xf5, 0xab, 0xb3, 0x04, 0x0c, 0x85, 0x0a, 0x05, 0xb4};
static const uint8_t pke_ecc_curve_secp224r1_n[28] = {0x3d, 0x2a, 0x5c, 0x5c, 0x45, 0x29, 0xdd, 0x13, 0x3e, 0xf0, 0xb8, 0xe0, 0xa2, 0x16, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp224r1_gx[28] = {0x21, 0x1d, 0x5c, 0x11, 0xd6, 0x80, 0x32, 0x34, 0x22, 0x11, 0xc2, 0x56, 0xd3, 0xc1, 0x03, 0x4a, 0xb9, 0x90, 0x13, 0x32, 0x7f, 0xbf, 0xb4, 0x6b, 0xbd, 0x0c, 0x0e, 0xb7};
static const uint8_t pke_ecc_curve_secp224r1_gy[28] = {0x34, 0x7e, 0x00, 0x85, 0x99, 0x81, 0xd5, 0x44, 0x64, 0x47, 0x07, 0x5a, 0xa0, 0x75, 0x43, 0xcd, 0xe6, 0xdf, 0x22, 0x4c, 0xfb, 0x23, 0xf7, 0xb5, 0x88, 0x63, 0x37, 0xbd};
static const uint8_t pke_ecc_curve_secp224r1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp224k1_p[28] = {0x6d, 0xe5, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp224k1_a[1] = {0x00};
static const uint8_t pke_ecc_curve_secp224k1_b[1] = {0x05};
static const uint8_t pke_ecc_curve_secp224k1_n[29] = {0xf7, 0xb1, 0x9f, 0x76, 0x71, 0xa9, 0xf0, 0xca, 0x84, 0x61, 0xec, 0xd2, 0xe8, 0xdc, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01};
static const uint8_t pke_ecc_curve_secp224k1_gx[28] = {0x5c, 0xa4, 0xb7, 0xb6, 0x0e, 0x65, 0x7e, 0x0f, 0xa9, 0x75, 0x70, 0xe4, 0xe9, 0x67, 0xa4, 0x69, 0xa1, 0x28, 0xfc, 0x30, 0xdf, 0x99, 0xf0, 0x4d, 0x33, 0x5b, 0x45, 0xa1};
static const uint8_t pke_ecc_curve_secp224k1_gy[28] = {0xa5, 0x61, 0x6d, 0x55, 0xdb, 0x4b, 0xca, 0xe2, 0x59, 0xbd, 0xb0, 0xc0, 0xf7, 0x19, 0xe3, 0xf7, 0xd6, 0xfb, 0xca, 0x82, 0x42, 0x34, 0xba, 0x7f, 0xed, 0x9f, 0x08, 0x7e};
static const uint8_t pke_ecc_curve_secp224k1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp256r1_p[32] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp256r1_a[32] = {0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp256r1_b[32] = {0x4b, 0x60, 0xd2, 0x27, 0x3e, 0x3c, 0xce, 0x3b, 0xf6, 0xb0, 0x53, 0xcc, 0xb0, 0x06, 0x1d, 0x65, 0xbc, 0x86, 0x98, 0x76, 0x55, 0xbd, 0xeb, 0xb3, 0xe7, 0x93, 0x3a, 0xaa, 0xd8, 0x35, 0xc6, 0x5a};
static const uint8_t pke_ecc_curve_secp256r1_n[32] = {0x51, 0x25, 0x63, 0xfc, 0xc2, 0xca, 0xb9, 0xf3, 0x84, 0x9e, 0x17, 0xa7, 0xad, 0xfa, 0xe6, 0xbc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp256r1_gx[32] = {0x96, 0xc2, 0x98, 0xd8, 0x45, 0x39, 0xa1, 0xf4, 0xa0, 0x33, 0xeb, 0x2d, 0x81, 0x7d, 0x03, 0x77, 0xf2, 0x40, 0xa4, 0x63, 0xe5, 0xe6, 0xbc, 0xf8, 0x47, 0x42, 0x2c, 0xe1, 0xf2, 0xd1, 0x17, 0x6b};
static const uint8_t pke_ecc_curve_secp256r1_gy[32] = {0xf5, 0x51, 0xbf, 0x37, 0x68, 0x40, 0xb6, 0xcb, 0xce, 0x5e, 0x31, 0x6b, 0x57, 0x33, 0xce, 0x2b, 0x16, 0x9e, 0x0f, 0x7c, 0x4a, 0xeb, 0xe7, 0x8e, 0x9b, 0x7f, 0x1a, 0xfe, 0xe2, 0x42, 0xe3, 0x4f};
static const uint8_t pke_ecc_curve_secp256r1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp256k1_a[1] = {0x00};
static const uint8_t pke_ecc_curve_secp256k1_b[1] = {0x07};
static const uint8_t pke_ecc_curve_secp256k1_p[32] = {0x2f, 0xfc, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp256k1_n[32] = {0x41, 0x41, 0x36, 0xd0, 0x8c, 0x5e, 0xd2, 0xbf, 0x3b, 0xa0, 0x48, 0xaf, 0xe6, 0xdc, 0xae, 0xba, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp256k1_gx[32] = {0x98, 0x17, 0xf8, 0x16, 0x5b, 0x81, 0xf2, 0x59, 0xd9, 0x28, 0xce, 0x2d, 0xdb, 0xfc, 0x9b, 0x02, 0x07, 0x0b, 0x87, 0xce, 0x95, 0x62, 0xa0, 0x55, 0xac, 0xbb, 0xdc, 0xf9, 0x7e, 0x66, 0xbe, 0x79};
static const uint8_t pke_ecc_curve_secp256k1_gy[32] = {0xb8, 0xd4, 0x10, 0xfb, 0x8f, 0xd0, 0x47, 0x9c, 0x19, 0x54, 0x85, 0xa6, 0x48, 0xb4, 0x17, 0xfd, 0xa8, 0x08, 0x11, 0x0e, 0xfc, 0xfb, 0xa4, 0x5d, 0x65, 0xc4, 0xa3, 0x26, 0x77, 0xda, 0x3a, 0x48};
static const uint8_t pke_ecc_curve_secp256k1_gz[1] = {1};

static const uint8_t pke_ecc_curve_secp384r1_p[48] = {0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp384r1_a[48] = {0xfc, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp384r1_b[48] = {0xef, 0x2a, 0xec, 0xd3, 0xed, 0xc8, 0x85, 0x2a, 0x9d, 0xd1, 0x2e, 0x8a, 0x8d, 0x39, 0x56, 0xc6, 0x5a, 0x87, 0x13, 0x50, 0x8f, 0x08, 0x14, 0x03, 0x12, 0x41, 0x81, 0xfe, 0x6e, 0x9c, 0x1d, 0x18, 0x19, 0x2d, 0xf8, 0xe3, 0x6b, 0x05, 0x8e, 0x98, 0xe4, 0xe7, 0x3e, 0xe2, 0xa7, 0x2f, 0x31, 0xb3};
static const uint8_t pke_ecc_curve_secp384r1_n[48] = {0x73, 0x29, 0xc5, 0xcc, 0x6a, 0x19, 0xec, 0xec, 0x7a, 0xa7, 0xb0, 0x48, 0xb2, 0x0d, 0x1a, 0x58, 0xdf, 0x2d, 0x37, 0xf4, 0x81, 0x4d, 0x63, 0xc7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_secp384r1_gx[48] = {0xb7, 0x0a, 0x76, 0x72, 0x38, 0x5e, 0x54, 0x3a, 0x6c, 0x29, 0x55, 0xbf, 0x5d, 0xf2, 0x02, 0x55, 0x38, 0x2a, 0x54, 0x82, 0xe0, 0x41, 0xf7, 0x59, 0x98, 0x9b, 0xa7, 0x8b, 0x62, 0x3b, 0x1d, 0x6e, 0x74, 0xad, 0x20, 0xf3, 0x1e, 0xc7, 0xb1, 0x8e, 0x37, 0x05, 0x8b, 0xbe, 0x22, 0xca, 0x87, 0xaa};
static const uint8_t pke_ecc_curve_secp384r1_gy[48] = {0x5f, 0x0e, 0xea, 0x90, 0x7c, 0x1d, 0x43, 0x7a, 0x9d, 0x81, 0x7e, 0x1d, 0xce, 0xb1, 0x60, 0x0a, 0xc0, 0xb8, 0xf0, 0xb5, 0x13, 0x31, 0xda, 0xe9, 0x7c, 0x14, 0x9a, 0x28, 0xbd, 0x1d, 0xf4, 0xf8, 0x29, 0xdc, 0x92, 0x92, 0xbf, 0x98, 0x9e, 0x5d, 0x6f, 0x2c, 0x26, 0x96, 0x4a, 0xde, 0x17, 0x36};
static const uint8_t pke_ecc_curve_secp384r1_gz[1] = {1};

/* rfc5639 https://datatracker.ietf.org/doc/html/rfc5639# */
static const uint8_t pke_ecc_curve_bp256r1_p[32] = {0x77, 0x53, 0x6e, 0x1f, 0x1d, 0x48, 0x13, 0x20, 0x28, 0x20, 0x26, 0xd5, 0x23, 0xf6, 0x3b, 0x6e, 0x72, 0x8d, 0x83, 0x9d, 0x90, 0x0a, 0x66, 0x3e, 0xbc, 0xa9, 0xee, 0xa1, 0xdb, 0x57, 0xfb, 0xa9};
static const uint8_t pke_ecc_curve_bp256r1_a[32] = {0xd9, 0xb5, 0x30, 0xf3, 0x44, 0x4b, 0x4a, 0xe9, 0x6c, 0x5c, 0xdc, 0x26, 0xc1, 0x55, 0x80, 0xfb, 0xe7, 0xff, 0x7a, 0x41, 0x30, 0x75, 0xf6, 0xee, 0x57, 0x30, 0x2c, 0xfc, 0x75, 0x09, 0x5a, 0x7d};
static const uint8_t pke_ecc_curve_bp256r1_b[32] = {0xb6, 0x07, 0x8c, 0xff, 0x18, 0xdc, 0xcc, 0x6b, 0xce, 0xe1, 0xf7, 0x5c, 0x29, 0x16, 0x84, 0x95, 0xbf, 0x7c, 0xd7, 0xbb, 0xd9, 0xb5, 0x30, 0xf3, 0x44, 0x4b, 0x4a, 0xe9, 0x6c, 0x5c, 0xdc, 0x26};
static const uint8_t pke_ecc_curve_bp256r1_n[32] = {0xa7, 0x56, 0x48, 0x97, 0x82, 0x0e, 0x1e, 0x90, 0xf7, 0xa6, 0x61, 0xb5, 0xa3, 0x7a, 0x39, 0x8c, 0x71, 0x8d, 0x83, 0x9d, 0x90, 0x0a, 0x66, 0x3e, 0xbc, 0xa9, 0xee, 0xa1, 0xdb, 0x57, 0xfb, 0xa9};
static const uint8_t pke_ecc_curve_bp256r1_gx[32] = {0x62, 0x32, 0xce, 0x9a, 0xbd, 0x53, 0x44, 0x3a, 0xc2, 0x23, 0xbd, 0xe3, 0xe1, 0x27, 0xde, 0xb9, 0xaf, 0xb7, 0x81, 0xfc, 0x2f, 0x48, 0x4b, 0x2c, 0xcb, 0x57, 0x7e, 0xcb, 0xb9, 0xae, 0xd2, 0x8b};
static const uint8_t pke_ecc_curve_bp256r1_gy[32] = {0x97, 0x69, 0x04, 0x2f, 0xc7, 0x54, 0x1d, 0x5c, 0x54, 0x8e, 0xed, 0x2d, 0x13, 0x45, 0x77, 0xc2, 0xc9, 0x1d, 0x61, 0x14, 0x1a, 0x46, 0xf8, 0x97, 0xfd, 0xc4, 0xda, 0xc3, 0x35, 0xf8, 0x7e, 0x54};
static const uint8_t pke_ecc_curve_bp256r1_gz[1] = {1};

static const uint8_t pke_ecc_curve_bp384r1_p[48] = {0x53, 0xec, 0x07, 0x31, 0x13, 0x00, 0x47, 0x87, 0x71, 0x1a, 0x1d, 0x90, 0x29, 0xa7, 0xd3, 0xac, 0x23, 0x11, 0xb7, 0x7f, 0x19, 0xda, 0xb1, 0x12, 0xb4, 0x56, 0x54, 0xed, 0x09, 0x71, 0x2f, 0x15, 0xdf, 0x41, 0xe6, 0x50, 0x7e, 0x6f, 0x5d, 0x0f, 0x28, 0x6d, 0x38, 0xa3, 0x82, 0x1e, 0xb9, 0x8c};
static const uint8_t pke_ecc_curve_bp384r1_a[48] = {0x26, 0x28, 0xce, 0x22, 0xdd, 0xc7, 0xa8, 0x04, 0xeb, 0xd4, 0x3a, 0x50, 0x4a, 0x81, 0xa5, 0x8a, 0x0f, 0xf9, 0x91, 0xba, 0xef, 0x65, 0x91, 0x13, 0x87, 0x27, 0xb2, 0x4f, 0x8e, 0xa2, 0xbe, 0xc2, 0xa0, 0xaf, 0x05, 0xce, 0x0a, 0x08, 0x72, 0x3c, 0x0c, 0x15, 0x8c, 0x3d, 0xc6, 0x82, 0xc3, 0x7b};
static const uint8_t pke_ecc_curve_bp384r1_b[48] = {0x11, 0x4c, 0x50, 0xfa, 0x96, 0x86, 0xb7, 0x3a, 0x94, 0xc9, 0xdb, 0x95, 0x02, 0x39, 0xb4, 0x7c, 0xd5, 0x62, 0xeb, 0x3e, 0xa5, 0x0e, 0x88, 0x2e, 0xa6, 0xd2, 0xdc, 0x07, 0xe1, 0x7d, 0xb7, 0x2f, 0x7c, 0x44, 0xf0, 0x16, 0x54, 0xb5, 0x39, 0x8b, 0x26, 0x28, 0xce, 0x22, 0xdd, 0xc7, 0xa8, 0x04};
static const uint8_t pke_ecc_curve_bp384r1_n[48] = {0x65, 0x65, 0x04, 0xe9, 0x02, 0x32, 0x88, 0x3b, 0x10, 0xc3, 0x7f, 0x6b, 0xaf, 0xb6, 0x3a, 0xcf, 0xa7, 0x25, 0x04, 0xac, 0x6c, 0x6e, 0x16, 0x1f, 0xb3, 0x56, 0x54, 0xed, 0x09, 0x71, 0x2f, 0x15, 0xdf, 0x41, 0xe6, 0x50, 0x7e, 0x6f, 0x5d, 0x0f, 0x28, 0x6d, 0x38, 0xa3, 0x82, 0x1e, 0xb9, 0x8c};
static const uint8_t pke_ecc_curve_bp384r1_gx[48] = {0x1e, 0xaf, 0xd4, 0x47, 0xe2, 0xb2, 0x87, 0xef, 0xaa, 0x46, 0xd6, 0x36, 0x34, 0xe0, 0x26, 0xe8, 0xe8, 0x10, 0xbd, 0x0c, 0xfe, 0xca, 0x7f, 0xdb, 0xe3, 0x4f, 0xf1, 0x7e, 0xe7, 0xa3, 0x47, 0x88, 0x6b, 0x3f, 0xc1, 0xb7, 0x81, 0x3a, 0xa6, 0xa2, 0xff, 0x45, 0xcf, 0x68, 0xf0, 0x64, 0x1c, 0x1d};
static const uint8_t pke_ecc_curve_bp384r1_gy[48] = {0x15, 0x53, 0x3c, 0x26, 0x41, 0x03, 0x82, 0x42, 0x11, 0x81, 0x91, 0x77, 0x21, 0x46, 0x46, 0x0e, 0x28, 0x29, 0x91, 0xf9, 0x4f, 0x05, 0x9c, 0xe1, 0x64, 0x58, 0xec, 0xfe, 0x29, 0x0b, 0xb7, 0x62, 0x52, 0xd5, 0xcf, 0x95, 0x8e, 0xeb, 0xb1, 0x5c, 0xa4, 0xc2, 0xf9, 0x20, 0x75, 0x1d, 0xbe, 0x8a};
static const uint8_t pke_ecc_curve_bp384r1_gz[1] = {1};

static const uint8_t pke_ecc_curve_bp512r1_p[64] = {0xf3, 0x48, 0x3a, 0x58, 0x56, 0x60, 0xaa, 0x28, 0x85, 0xc6, 0x82, 0x2d, 0x2f, 0xff, 0x81, 0x28, 0xe6, 0x80, 0xa3, 0xe6, 0x2a, 0xa1, 0xcd, 0xae, 0x42, 0x68, 0xc6, 0x9b, 0x00, 0x9b, 0x4d, 0x7d, 0x71, 0x08, 0x33, 0x70, 0xca, 0x9c, 0x63, 0xd6, 0x0e, 0xd2, 0xc9, 0xb3, 0xb3, 0x8d, 0x30, 0xcb, 0x07, 0xfc, 0xc9, 0x33, 0xae, 0xe6, 0xd4, 0x3f, 0x8b, 0xc4, 0xe9, 0xdb, 0xb8, 0x9d, 0xdd, 0xaa};
static const uint8_t pke_ecc_curve_bp512r1_a[64] = {0xca, 0x94, 0xfc, 0x77, 0x4d, 0xac, 0xc1, 0xe7, 0xb9, 0xc7, 0xf2, 0x2b, 0xa7, 0x17, 0x11, 0x7f, 0xb5, 0xc8, 0x9a, 0x8b, 0xc9, 0xf1, 0x2e, 0x0a, 0xa1, 0x3a, 0x25, 0xa8, 0x5a, 0x5d, 0xed, 0x2d, 0xbc, 0x63, 0x98, 0xea, 0xca, 0x41, 0x34, 0xa8, 0x10, 0x16, 0xf9, 0x3d, 0x8d, 0xdd, 0xcb, 0x94, 0xc5, 0x4c, 0x23, 0xac, 0x45, 0x71, 0x32, 0xe2, 0x89, 0x3b, 0x60, 0x8b, 0x31, 0xa3, 0x30, 0x78};
static const uint8_t pke_ecc_curve_bp512r1_b[64] = {0x23, 0xf7, 0x16, 0x80, 0x63, 0xbd, 0x09, 0x28, 0xdd, 0xe5, 0xba, 0x5e, 0xb7, 0x50, 0x40, 0x98, 0x67, 0x3e, 0x08, 0xdc, 0xca, 0x94, 0xfc, 0x77, 0x4d, 0xac, 0xc1, 0xe7, 0xb9, 0xc7, 0xf2, 0x2b, 0xa7, 0x17, 0x11, 0x7f, 0xb5, 0xc8, 0x9a, 0x8b, 0xc9, 0xf1, 0x2e, 0x0a, 0xa1, 0x3a, 0x25, 0xa8, 0x5a, 0x5d, 0xed, 0x2d, 0xbc, 0x63, 0x98, 0xea, 0xca, 0x41, 0x34, 0xa8, 0x10, 0x16, 0xf9, 0x3d};
static const uint8_t pke_ecc_curve_bp512r1_n[64] = {0x69, 0x00, 0xa9, 0x9c, 0x82, 0x96, 0x87, 0xb5, 0xdd, 0xda, 0x5d, 0x08, 0x81, 0xd3, 0xb1, 0x1d, 0x47, 0x10, 0xac, 0x7f, 0x19, 0x61, 0x86, 0x41, 0x19, 0x26, 0xa9, 0x4c, 0x41, 0x5c, 0x3e, 0x55, 0x70, 0x08, 0x33, 0x70, 0xca, 0x9c, 0x63, 0xd6, 0x0e, 0xd2, 0xc9, 0xb3, 0xb3, 0x8d, 0x30, 0xcb, 0x07, 0xfc, 0xc9, 0x33, 0xae, 0xe6, 0xd4, 0x3f, 0x8b, 0xc4, 0xe9, 0xdb, 0xb8, 0x9d, 0xdd, 0xaa};
static const uint8_t pke_ecc_curve_bp512r1_gx[64] = {0x22, 0xf8, 0xb9, 0xbc, 0x09, 0x22, 0x35, 0x8b, 0x68, 0x5e, 0x6a, 0x40, 0x47, 0x50, 0x6d, 0x7c, 0x5f, 0x7d, 0xb9, 0x93, 0x7b, 0x68, 0xd1, 0x50, 0x8d, 0xd4, 0xd0, 0xe2, 0x78, 0x1f, 0x3b, 0xff, 0x8e, 0x09, 0xd0, 0xf4, 0xee, 0x62, 0x3b, 0xb4, 0xc1, 0x16, 0xd9, 0xb5, 0x70, 0x9f, 0xed, 0x85, 0x93, 0x6a, 0x4c, 0x9c, 0x2e, 0x32, 0x21, 0x5a, 0x64, 0xd9, 0x2e, 0xd8, 0xbd, 0xe4, 0xae, 0x81};
static const uint8_t pke_ecc_curve_bp512r1_gy[64] = {0x92, 0x08, 0xd8, 0x3a, 0x0f, 0x1e, 0xcd, 0x78, 0x06, 0x54, 0xf0, 0xa8, 0x2f, 0x2b, 0xca, 0xd1, 0xae, 0x63, 0x27, 0x8a, 0xd8, 0x4b, 0xca, 0x5b, 0x5e, 0x48, 0x5f, 0x4a, 0x49, 0xde, 0xdc, 0xb2, 0x11, 0x81, 0x1f, 0x88, 0x5b, 0xc5, 0x00, 0xa0, 0x1a, 0x7b, 0xa5, 0x24, 0x00, 0xf7, 0x09, 0xf2, 0xfd, 0x22, 0x78, 0xcf, 0xa9, 0xbf, 0xea, 0xc0, 0xec, 0x32, 0x63, 0x56, 0x5d, 0x38, 0xde, 0x7d};
static const uint8_t pke_ecc_curve_bp512r1_gz[1] = {1};

// https://datatracker.ietf.org/doc/html/rfc7748#section-4.1
static const uint8_t pke_ecc_curve_curve25519_p[32] = {0xed, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f};
static const uint8_t pke_ecc_curve_curve25519_a[3] = {0x06, 0x6d, 0x07};
static const uint8_t pke_ecc_curve_curve25519_b[1] = {0x01};
static const uint8_t pke_ecc_curve_curve25519_gz[1] = {1};

static const uint8_t pke_ecc_curve_curve448_p[56] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
static const uint8_t pke_ecc_curve_curve448_a[3] = {0xa6, 0x62, 0x02};
static const uint8_t pke_ecc_curve_curve448_b[1] = {0x01};
static const uint8_t pke_ecc_curve_curve448_gz[1] = {1};

/* ed25519 */
static const uint8_t pke_ecc_curve_ed25519_a[32] = {0xec, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f};
static const uint8_t pke_ecc_curve_ed25519_d[32] = {0xa3, 0x78, 0x59, 0x13, 0xca, 0x4d, 0xeb, 0x75, 0xab, 0xd8, 0x41, 0x41, 0x4d, 0x0a, 0x70, 0x00, 0x98, 0xe8, 0x79, 0x77, 0x79, 0x40, 0xc7, 0x8c, 0x73, 0xfe, 0x6f, 0x2b, 0xee, 0x6c, 0x03, 0x52};
static const uint8_t pke_ecc_curve_ed25519_p[32] = {0xed, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f};
static const uint8_t pke_ecc_curve_ed25519_n[32] = {0xed, 0xd3, 0xf5, 0x5c, 0x1a, 0x63, 0x12, 0x58, 0xd6, 0x9c, 0xf7, 0xa2, 0xde, 0xf9, 0xde, 0x14, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10};
static const uint8_t pke_ecc_curve_ed25519_gx[32] = {0x1a, 0xd5, 0x25, 0x8f, 0x60, 0x2d, 0x56, 0xc9, 0xb2, 0xa7, 0x25, 0x95, 0x60, 0xc7, 0x2c, 0x69, 0x5c, 0xdc, 0xd6, 0xfd, 0x31, 0xe2, 0xa4, 0xc0, 0xfe, 0x53, 0x6e, 0xcd, 0xd3, 0x36, 0x69, 0x21};
static const uint8_t pke_ecc_curve_ed25519_gy[32] = {0x58, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66};
static const uint8_t pke_ecc_curve_ed25519_gz[1] = {1};

#define PKE_ECC_WRITE_ENGINE(dst, src, len) (pke_engine_write((dst), (src), (len), PKE_ECC_PARAMETER_SIZE))

#define PKE_CONTROL_BIT_SET_CURVE(ctrl_reg, grp) do { \
	(ctrl_reg) &= ~PKE_MASK_CONTROL_MODE_MAIN; \
    (ctrl_reg) |= PKE_CONTROL_MODE_MAIN((grp)->curve_field); \
    if ((grp)->curve_is_Montgomery) { \
        (ctrl_reg) |= PKE_BIT_CONTROL_MODE_CURVE; \
    } \
    (ctrl_reg) &= ~PKE_MASK_CONTROL_PRECISE_LENGTH; \
    (ctrl_reg) |= PKE_CONTROL_PRECISE_LENGTH((grp)->precise_bits); \
} while(0)

/**
 * @brief  Initialize ECC curve parameters
 * @param  grp: Pointer to the pke_ecp_group structure.
 * @param  curve_id: One of pke_ecp_curve_id enum
 * @retval RTK_SUCCESS
 * @retval RTK_FAIL (ROM code unsupported curve ID)
 */
int pke_ecp_group_init_in_rom(pke_ecp_group *grp, pke_ecp_curve_id curve_id)
{
	memset((void *)grp, 0, sizeof(pke_ecp_group));

	switch (curve_id) {
	/* ECDSA */
	case PKE_ECP_CURVE_SECP192R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 192;
		grp->A_size = 24;
		grp->B_size = 24;
		grp->P_size = 24;
		grp->N_size = 24;
		grp->Gx_size = 24;
		grp->Gy_size = 24;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp192r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp192r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp192r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp192r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp192r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp192r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp192r1_gz;
		break;

	case PKE_ECP_CURVE_SECP224R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 224;
		grp->A_size = 28;
		grp->B_size = 28;
		grp->P_size = 28;
		grp->N_size = 28;
		grp->Gx_size = 28;
		grp->Gy_size = 28;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp224r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp224r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp224r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp224r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp224r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp224r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp224r1_gz;
		break;

	case PKE_ECP_CURVE_SECP256R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 256;
		grp->A_size = 32;
		grp->B_size = 32;
		grp->P_size = 32;
		grp->N_size = 32;
		grp->Gx_size = 32;
		grp->Gy_size = 32;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp256r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp256r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp256r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp256r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp256r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp256r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp256r1_gz;
		break;

	case PKE_ECP_CURVE_SECP384R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 384;
		grp->A_size = 48;
		grp->B_size = 48;
		grp->P_size = 48;
		grp->N_size = 48;
		grp->Gx_size = 48;
		grp->Gy_size = 48;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp384r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp384r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp384r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp384r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp384r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp384r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp384r1_gz;
		break;

	case PKE_ECP_CURVE_BP256R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 256;
		grp->A_size = 32;
		grp->B_size = 32;
		grp->P_size = 32;
		grp->N_size = 32;
		grp->Gx_size = 32;
		grp->Gy_size = 32;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_bp256r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_bp256r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_bp256r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_bp256r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_bp256r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_bp256r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_bp256r1_gz;
		break;

	case PKE_ECP_CURVE_BP384R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 384;
		grp->A_size = 48;
		grp->B_size = 48;
		grp->P_size = 48;
		grp->N_size = 48;
		grp->Gx_size = 48;
		grp->Gy_size = 48;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_bp384r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_bp384r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_bp384r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_bp384r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_bp384r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_bp384r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_bp384r1_gz;
		break;

	case PKE_ECP_CURVE_BP512R1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 512;
		grp->A_size = 64;
		grp->B_size = 64;
		grp->P_size = 64;
		grp->N_size = 64;
		grp->Gx_size = 64;
		grp->Gy_size = 64;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_bp512r1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_bp512r1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_bp512r1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_bp512r1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_bp512r1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_bp512r1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_bp512r1_gz;
		break;

	case PKE_ECP_CURVE_CURVE25519:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_EDWARDS_MONTGOMERY;
		grp->curve_is_Montgomery = 1;
		grp->precise_bits = 256;
		grp->A_size = 3;
		grp->B_size = 1;
		grp->P_size = 32;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_curve25519_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_curve25519_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_curve25519_p;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_curve25519_gz;
		break;

	case PKE_ECP_CURVE_SECP192K1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 192;
		grp->A_size = 1;
		grp->B_size = 1;
		grp->P_size = 24;
		grp->N_size = 24;
		grp->Gx_size = 24;
		grp->Gy_size = 24;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp192k1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp192k1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp192k1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp192k1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp192k1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp192k1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp192k1_gz;
		break;

	case PKE_ECP_CURVE_SECP224K1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 225;
		grp->A_size = 1;
		grp->B_size = 1;
		grp->P_size = 28;
		grp->N_size = 29;
		grp->Gx_size = 28;
		grp->Gy_size = 28;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp224k1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp224k1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp224k1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp224k1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp224k1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp224k1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp224k1_gz;
		break;

	case PKE_ECP_CURVE_SECP256K1:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_ECC_PRIME;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 256;
		grp->A_size = 1;
		grp->B_size = 1;
		grp->P_size = 32;
		grp->N_size = 32;
		grp->Gx_size = 32;
		grp->Gy_size = 32;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_secp256k1_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_secp256k1_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_secp256k1_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_secp256k1_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_secp256k1_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_secp256k1_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_secp256k1_gz;
		break;

	case PKE_ECP_CURVE_CURVE448:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_EDWARDS_MONTGOMERY;
		grp->curve_is_Montgomery = 1;
		grp->precise_bits = 448;
		grp->A_size = 3;
		grp->B_size = 1;
		grp->P_size = 56;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_curve448_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_curve448_b;
		grp->P_p = (uint8_t *)pke_ecc_curve_curve448_p;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_curve448_gz;
		break;

	/* EdDSA */
	case PKE_ECP_CURVE_ED25519:
		grp->curve_id = curve_id;
		grp->curve_field = PKE_MODE_MAIN_EDWARDS_MONTGOMERY;
		grp->curve_is_Montgomery = 0;
		grp->precise_bits = 256;
		grp->A_size = 32;
		grp->B_size = 32;
		grp->P_size = 32;
		grp->N_size = 32;
		grp->Gx_size = 32;
		grp->Gy_size = 32;
		grp->Gz_size = 1;
		grp->A_p = (uint8_t *)pke_ecc_curve_ed25519_a;
		grp->B_p = (uint8_t *)pke_ecc_curve_ed25519_d;
		grp->P_p = (uint8_t *)pke_ecc_curve_ed25519_p;
		grp->N_p = (uint8_t *)pke_ecc_curve_ed25519_n;
		grp->Gx_p = (uint8_t *)pke_ecc_curve_ed25519_gx;
		grp->Gy_p = (uint8_t *)pke_ecc_curve_ed25519_gy;
		grp->Gz_p = (uint8_t *)pke_ecc_curve_ed25519_gz;
		break;

	default:
		return RTK_FAIL;
	}
	return RTK_SUCCESS;
}

/**
 * @brief  Set ECC curve parameter into PKE TMEM memory
 * @param  grp: Pointer to the pke_ecp_group structure.
 * @retval RTK_SUCCESS
 */
int pke_ecp_set_tmem_curve_parameter(pke_ecp_group *grp)
{
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_A, grp->A_p, grp->A_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_B, grp->B_p, grp->B_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_P, grp->P_p, grp->P_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_N, grp->N_p, grp->N_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_G_x, grp->Gx_p, grp->Gx_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_G_y, grp->Gy_p, grp->Gy_size);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_G_z, grp->Gz_p, grp->Gz_size);
	return RTK_SUCCESS;
}

/**
 * @brief  Per-process ECDSA HASH
 * @param  buf_out: HASH ready for PKE engine
 * @param  hash_in: HASH result from SW lib or HW HMAC engine
 * @param  hash_len_byte: HASH length in bytes
 * @param  precise_bit: ECC curve precise in bit
 * @retval None
 */
void pke_ecdsa_lalu_hash_process(uint8_t *buf_out, uint8_t *hash_in, uint32_t hash_len_byte, uint32_t precise_bit)
{
	uint32_t precise_byte = (precise_bit + 7) / 8;
	uint32_t N = precise_byte * 8 - precise_bit;
	uint32_t use_size = hash_len_byte > precise_byte ? precise_byte : hash_len_byte;
	uint8_t carry = 0;
	uint8_t current;

	memcpy(buf_out, hash_in, use_size);
	pke_reverse_array(buf_out, use_size);

	if (N > 0) {
		for (int i = precise_byte - 1; i >= 0; --i) {
			current = (uint8_t)buf_out[i];
			buf_out[i] = (current >> N) | carry;
			carry = (current & ((1 << N) - 1)) << (8 - N);
		}
	}
}

int pke_ecc_check_signature_valid(uint8_t *sign_r, uint8_t *sign_s, uint8_t precise_byte)
{
	bool r_is_invalid = true;
	bool s_is_invalid = true;

	/* R / S are not zeros */
	for (uint8_t i = 0; i < precise_byte; i++) {
		if (sign_r[i] != 0) {
			r_is_invalid = false;
		}
		if (sign_s[i] != 0) {
			s_is_invalid = false;
		}
	}

	if (r_is_invalid == false && s_is_invalid == false) {
		return RTK_SUCCESS;
	} else {
		return RTK_FAIL;
	}
}

/**
 * @brief  Verify an ECDSA signature (r, s) for the given hash using the specified public key and elliptic curve group.
 * @param  grp: Pointer to the pke_ecp_group structure.
 * @param  pub_key_x_p: Pointer to the x-coordinate of the public key.
 * @param  pub_key_y_p: Pointer to the y-coordinate of the public key.
 * @param  HASH_p: Pointer to the hash of the message whose signature is to be verified.
 * @param  HASH_size_byte: Size of the hash in bytes.
 * @param  sign_r: Pointer to the 'r' component of the provided signature.
 * @param  sign_s: Pointer to the 's' component of the provided signature.
 * @return Returns 0 if the signature is valid, or an error code if the verification fails.
 */
int pke_ecdsa_read_signature(pke_ecp_group *grp, uint8_t *pub_key_x_p, uint8_t *pub_key_y_p,
							 uint8_t *HASH_p, uint8_t HASH_size_byte,
							 uint8_t *sign_r, uint8_t *sign_s)
{
	PKE_TypeDef *PKE = pke_get_pke_addr();
	uint32_t ctrl_reg = 0;
	uint8_t precise_byte = grp->precise_bits / 8;
	uint16_t HASH_size_bit = HASH_size_byte * 8;
	int ret = RTK_FAIL;

	/* Variables for Fault Injection Hardening (FIH) */
	volatile uint32_t fih_chk_cmp = FIH_CHECK_FAIL;
	volatile uint32_t fih_chk_nz  = FIH_CHECK_FAIL;

	if (pke_ecc_check_signature_valid(sign_r, sign_s, precise_byte) != RTK_SUCCESS) {
		return RTK_FAIL;
	}

	pke_lock_mutex();

	/* 1. set parameter to TMEM */
	pke_ecp_set_tmem_curve_parameter(grp);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_ECDSA_PUBKEY_x, pub_key_x_p, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_ECDSA_PUBKEY_y, pub_key_y_p, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_ECDSA_SIGN_R, sign_r, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_ECDSA_SIGN_S, sign_s, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_ECDSA_HASH_LEN, &HASH_size_bit, 2);
	if (HASH_size_byte > ((grp->precise_bits + 7) / 8)) {
		PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_HASH, HASH_p, ((grp->precise_bits + 7) / 8));
	} else {
		PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_HASH, HASH_p, HASH_size_byte);
	}

	/* 2. start simplify_ecdsa_verify */
	pke_function_set_entry(PKE_FUNCTION_ENTRY_SIMPLIFY_ECDSA_VERIFY);
	PKE_CONTROL_BIT_SET_CURVE(ctrl_reg, grp);
	ctrl_reg |= PKE_BIT_CONTROL_HASH_READY;
	ctrl_reg |= PKE_BIT_CONTROL_OTHER_FUNCTION;
	ctrl_reg |= PKE_BIT_CONTROL_START;
	PKE->PKE_CONTROL = ctrl_reg;
	ret = __inline_pke_engine_check_status(PKE_BIT_STATUS_FINISH);
	if (ret != RTK_SUCCESS) {
		goto cleanup;
	}

	/* 4. Read verify result from TMEM with FIH protection
	[FIH] Force reset 'ret' to FAIL before checks.
	   Defends against instruction skipping attacks that bypass the checks below. */
	ret = RTK_FAIL;

	/* Check 1: Computed R' must not be all zeros (Invalid Point) */
	fih_chk_nz  = pke_secure_is_not_zero((void *)PKE_ECC_TMEM_ADDR_ECDSA_VERIFY_RQ,
										 precise_byte);

	/* Check 2: Computed R' (VERIFY_RQ) must match Input R (SIGN_R) */
	fih_chk_cmp = pke_secure_memcmp((void *)PKE_ECC_TMEM_ADDR_ECDSA_SIGN_R,
									(void *)PKE_ECC_TMEM_ADDR_ECDSA_VERIFY_RQ,
									precise_byte);

	/* [FIH] Final Judgment: Use logical AND on Magic Words.
	   Only update 'ret' to SUCCESS if both checks explicitly pass. */
	if ((fih_chk_nz == FIH_CHECK_PASS) && (fih_chk_cmp == FIH_CHECK_PASS)) {
		ret = RTK_SUCCESS;
	}

	/* 5. Clear PKE_Status and function entry */
cleanup:
	PKE->PKE_STATUS = 0x0;
	pke_function_set_entry(PKE_FUNCTION_ENTRY_CLEAR);
	pke_unlock_mutex();
	return ret;
}

/**
 * @brief  Verify an EdDSA signature (R, S) using the provided public key and additional buffers.
 * @param  grp: Pointer to the pke_ecp_group structure.
 * @param  pub_key_p: Pointer to the buffer containing the public key used for signature verification.
 * @param  k_buf: Pointer to the buffer used for storing intermediate values during the verification process.
 * @param  k_size: Size of the k_buf buffer in bytes.
 * @param  sign_r: Pointer to the buffer containing the R component of the signature.
 * @param  sign_s: Pointer to the buffer containing the S component of the signature.
 * @return Returns 0 on successful verification, or an error code on failure.
 */
int pke_eddsa_read_signature(pke_ecp_group *grp, uint8_t *pub_key_p,
							 uint8_t *k_buf, uint8_t k_size, uint8_t *sign_r, uint8_t *sign_s)
{
	PKE_TypeDef *PKE = pke_get_pke_addr();
	uint32_t ctrl_reg = 0;
	uint8_t precise_byte = grp->precise_bits / 8;
	int ret = RTK_FAIL;

	/* Variables for Fault Injection Hardening (FIH) */
	volatile uint32_t fih_chk_x = FIH_CHECK_FAIL;
	volatile uint32_t fih_chk_y = FIH_CHECK_FAIL;

	if (pke_ecc_check_signature_valid(sign_r, sign_s, precise_byte) != RTK_SUCCESS) {
		return RTK_FAIL;
	}

	pke_lock_mutex();

	/* 1. set parameter to TMEM */
	pke_ecp_set_tmem_curve_parameter(grp);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_EdDSA_PUBKEY, pub_key_p, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_EdDSA_SIGN_R, sign_r, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_EdDSA_SIGN_S, sign_s, precise_byte);
	PKE_ECC_WRITE_ENGINE(PKE_ECC_TMEM_ADDR_EdDSA_VERIFY_MSG, k_buf, k_size);

	/* 2. start simplify_ecdsa_sign */
	pke_function_set_entry(PKE_FUNCTION_ENTRY_SIMPLIFY_EDDSA_VERIFY);
	PKE_CONTROL_BIT_SET_CURVE(ctrl_reg, grp);
	ctrl_reg |= PKE_BIT_CONTROL_OTHER_FUNCTION;
	ctrl_reg |= PKE_BIT_CONTROL_START;
	PKE->PKE_CONTROL = ctrl_reg;

	/* 3. Wait for calculation */
	ret = __inline_pke_engine_check_status(PKE_BIT_STATUS_FINISH);
	if (ret != RTK_SUCCESS) {
		goto cleanup;
	}

	/* 4. Read verify result from TMEM with FIH protection
	[FIH] Force reset 'ret' to FAIL before checks.
	   Defends against instruction skipping attacks. */
	ret = RTK_FAIL;

	/* Check 1: Compare X coordinates of calculated point A and point B */
	fih_chk_x = pke_secure_memcmp((void *)PKE_ECC_TMEM_ADDR_EdDSA_VERIFY_B_x,
								  (void *)PKE_ECC_TMEM_ADDR_EdDSA_VERIFY_A_x,
								  precise_byte);

	/* Check 2: Compare Y coordinates of calculated point A and point B */
	fih_chk_y = pke_secure_memcmp((void *)PKE_ECC_TMEM_ADDR_EdDSA_VERIFY_B_y,
								  (void *)PKE_ECC_TMEM_ADDR_EdDSA_VERIFY_A_y,
								  precise_byte);

	/* [FIH] Final Judgment: Both X and Y coordinates must match.
	   Using bitwise AND on Magic Words to prevent short-circuit evaluation attacks. */
	if ((fih_chk_x == FIH_CHECK_PASS) && (fih_chk_y == FIH_CHECK_PASS)) {
		ret = RTK_SUCCESS;
	}

	/* 5. Clear PKE_Status and function entry */
cleanup:
	PKE->PKE_STATUS = 0x0;
	pke_function_set_entry(PKE_FUNCTION_ENTRY_CLEAR);
	pke_unlock_mutex();
	return ret;
}

/**
 * @brief  Compute the k value used in the Ed25519 signing process.
 *         This is done by performing SHA512 hashing on the concatenation of specific elements, including the signature value R, encoded public key, and the message.
 * @param  message: Pointer to the message buffer that will be hashed.
 * @param  msg_len: Length of the message in bytes.
 * @param  pub_key_encoded: Pointer to the buffer containing the encoded public key. This is used in the computation of k.
 * @param  sign_R: Pointer to the buffer containing the R component of the signature.
 * @param  out_buf_k: Pointer to the buffer where the computed k value will be stored.
 * @param  out_buf_size: Size of the out_buf_k buffer in bytes. It should be at least 64 bytes since SHA512 produces a 64-byte hash.
 * @return Returns 0 on success, or an error code on failure.
 * @note   The function computes k as SHA512(dom2(F,C) || R || A || PH(M)), where:
 *         - dom2(F,C) is empty for Ed25519.
 *         - R is the signature value R.
 *         - A is the encoded public key.
 *         - PH(M) is the message hash (or the message itself, depending on the implementation).
 */
int pke_eddsa_ed25519_get_k_value(uint8_t *message, size_t msg_len, uint8_t *pub_key_encoded, uint8_t *sign_R, uint8_t *out_buf_k, size_t out_buf_size)
{
	int ret = RTK_FAIL;

	if (out_buf_size < 64) {
		return 1;
	}

	uint8_t sign_R_swap[32];
	memcpy(sign_R_swap, sign_R, 32);
	pke_reverse_array(sign_R_swap, 32);

	uint8_t pub_key_encoded_swap[32];
	memcpy(pub_key_encoded_swap, pub_key_encoded, 32);
	pke_reverse_array(pub_key_encoded_swap, 32);

	SHA_context hw_ctx;
	CRYPTO_CHK(crypto_sha2_init(&hw_ctx, SHA_512), RTK_FAIL);
	CRYPTO_CHK(crypto_sha2_update(&hw_ctx, sign_R_swap, NULL, 32), RTK_FAIL);
	CRYPTO_CHK(crypto_sha2_update(&hw_ctx, pub_key_encoded_swap, NULL, 32), RTK_FAIL);
	CRYPTO_CHK(crypto_sha2_update(&hw_ctx, message, NULL, msg_len), RTK_FAIL);
	CRYPTO_CHK(crypto_sha2_final(&hw_ctx, out_buf_k), RTK_FAIL);

	pke_reverse_array(out_buf_k, 64);

	return RTK_SUCCESS;

exit:
	return ret;
}

/**
 * @brief  Verify an Ed25519 digital signature for the given message using the provided public key.
 * @param  message: Pointer to the message buffer that was signed.
 * @param  msg_len: Length of the message in bytes.
 * @param  pub_key_le: Pointer to the buffer containing the public key in little-endian format.
 *                     This key is used to verify the authenticity of the signature.
 * @param  sign_r: Pointer to the buffer containing the R component of the signature.
 * @param  sign_s: Pointer to the buffer containing the S component of the signature.
 * @return Returns 0 if the signature is valid and matches the provided message and public key, or an error code if the verification fails.
 * @note   This function performs the Ed25519 signature verification process.
 *         It checks that the signature (R, S) corresponds to the message under the given public key.
 *         Ensure that all input buffers are correctly initialized and match the expected sizes for Ed25519, typically 32 bytes for each component.
 */
int pke_eddsa_ed25519_read_signature(uint8_t *message, size_t msg_len, uint8_t *pub_key_le,
									 uint8_t *sign_r, uint8_t *sign_s)
{
	uint8_t para_k_buf[64];
	pke_eddsa_ed25519_get_k_value(message, msg_len, pub_key_le, sign_r, para_k_buf, 64);

	pke_ecp_group grp;
	pke_ecp_group_init_in_rom(&grp, PKE_ECP_CURVE_ED25519);
	return pke_eddsa_read_signature(&grp, pub_key_le, para_k_buf, 64, sign_r, sign_s);
}
